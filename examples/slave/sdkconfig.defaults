## examples/slave/sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_SECONDARY_NONE=y
CONFIG_LWIP_TCPIP_TASK_STACK_SIZE=4096
CONFIG_LWIP_PPP_VJ_HEADER_COMPRESSION=n
```
